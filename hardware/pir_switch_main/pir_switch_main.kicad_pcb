# Repository na-ka-no/am312_config

File README.md:

# am312_config

AM312 人感センサー + XIAO BLE で、人が近づいたらキー操作を送る ZMK ファームウェア。

## 配線

| 部品 | 部品側の端子 | つなぐ先 |
|---|---|---|
| AM312 | VCC / GND / OUT | XIAO 3V3 / GND / D0 |
| スイッチA（モード1） | 2本の足（向きなし） | XIAO D1 と GND |
| スイッチB（モード2） | 2本の足（向きなし） | XIAO D2 と GND |
| 昇圧モジュール（aaa-boost-module-v2） | 1 GND | XIAO GND、電池− |
| | 2 5V | XIAO 5V（USB 接続時の逆流防止に必須） |
| | 3 SNS | XIAO D3（電池残量の測定） |
| | 4 MCU | XIAO 裏面の BAT+ パッド |
| | 5 BAT | 電源スイッチ → 電池+（エネループ単4 1本） |

- LED は XIAO 基板上のフルカラーLEDの緑と青を使う（配線不要）。
- D4・D5・D6〜D10 は空き。
- 電池残量はニッケル水素用の換算表（`src/battery_nimh.c`）で計算し、Bluetooth で PC に送る（Windows の「Bluetooth とデバイス」に表示される）。

## 本体の操作

| 操作 | 動作 |
|---|---|
| センサー反応 | 今のモードのキーを送る。次に反応できるまでモードの色でLEDが点く |
| スイッチA / B 単押し | 動作確認（今のモードのキーを送り、モードの色でLEDが点滅） |
| スイッチA 3秒長押し | モード1（緑）にする |
| スイッチB 3秒長押し | モード2（青）にする |
| 両方 単押し | センサー反応時のLED表示を ON / OFF |
| 両方 3秒長押し | Bluetooth のペアリング情報をすべて消す |

LED の色はモード1が緑、モード2が青。電源を入れた直後は電池残量を2秒間表示する（50%以上：緑、20〜49%：黄、20%未満：赤。電池がないときは表示しない）。ペアリング削除のときは緑と青が同時に点滅する（水色に見える）。モードと LED の ON/OFF は電源を切っても保たれる。

## 送るキーを変える

1. [docs/index.html](docs/index.html) をブラウザで開く
2. モードごとに送るキーの手順を決めて「設定ファイルをダウンロード」を押す
3. XIAO BLE のリセットボタンを2回押し、出てきたドライブに `pir_config.uf2` をコピーする

設定ファイルはフラッシュの設定領域（`0xE9000`、4KB）だけを書き換えるので、ファームウェア本体を書き直す必要はない。
ファームウェアを更新しても設定は残る。初期設定に戻すときは「初期設定に戻すファイル」を書き込む。

## 構成

| パス | 内容 |
|---|---|
| `config/boards/shields/pir_switch/` | シールド定義（配線・キーマップ・設定領域） |
| `src/behavior_pir_switch.c` | センサー・スイッチ・LED・設定領域を扱う ZMK の動作 |
| `src/battery_nimh.c` | エネループ1本の電池残量を測るセンサー |
| `include/dt-bindings/zmk/pir_switch.h` | キーマップで使うコマンド（`PIR_TRIGGER` など） |
| `dts/bindings/`, `Kconfig`, `CMakeLists.txt`, `zephyr/module.yml` | 上の動作を ZMK に組み込むための定義 |
| `docs/index.html` | 設定ファイル（.uf2）を作る Web ページ |

## KiCad design hardware/pir_switch_main/pir_switch_main.kicad_pcb

File hardware/pir_switch_main/README.md:

# PIR Switch メイン基板 v1

XIAO nRF52840・Choc スイッチ2個・単4電池ホルダーを載せ、昇圧モジュール（aaa-boost-module-v2）と AM312 を差し込むメイン基板です。

- 基板サイズ：**62 × 41mm**、2層（両面 GND ベタ）
- 部品はすべて挿入部品（はんだごてで組み立て可能）
- ERC（回路図）・DRC（基板）・回路図と基板の一致チェック：すべて 0 件（KiCad 9.0.3）

| 表面 | 裏面 |
|---|---|
|  |  |

## 部品

| 番号 | 部品 | 備考 |
|---|---|---|
| U1 | Seeed XIAO nRF52840 | ピンヘッダ（1×7 を2本）で実装。USB 端子は基板の右端 |
| SW1 | Kailh Choc V1（PG1350） | スイッチA（モード1）。基板に直接はんだ付け |
| SW2 | Kailh Choc V1（PG1350） | スイッチB（モード2） |
| BT1 | Keystone 2466（単4 1本用ホルダー） | 左が＋、右が− |
| J1 | 1×3 ピンヘッダ（2.54mm） | AM312 を電線でつなぐ（VCC / OUT / GND） |
| J2 | 1×5 ピンヘッダ（2.54mm） | 昇圧モジュールを差す（1 GND, 2 5V, 3 SNS, 4 MCU, 5 BAT）。角パッド = 1番（右端） |
| J3 | 1×2 ピンヘッダ（2.54mm） | 電源スイッチを電線でつなぐ（BAT+ / SW） |
| H1〜H3 | M2 取付穴 | 右上は XIAO があるため穴なし |

## 回路

| ネット | つながる先 |
|---|---|
| D0_PIR | XIAO D0 ― J1 OUT |
| D1_SW_A | XIAO D1 ― SW1 |
| D2_SW_B | XIAO D2 ― SW2 |
| BAT_SNS | XIAO D3 ― J2 SNS |
| +3V3 | XIAO 3V3 ― J1 VCC |
| VBUS | XIAO 5V ― J2 5V |
| VBAT | XIAO 裏面の VBAT パッド（U1 の 15 番の穴）― J2 MCU |
| BAT_SW | J2 BAT ― J3 SW |
| BAT_P | J3 BAT+ ― 電池＋ |
| GND | XIAO GND、SW1・SW2、J1 GND、J2 GND、電池− |

ファームウェア（`config/boards/shields/pir_switch/`）の配線と同じです。

## 組み立ての注意

1. **XIAO の VBAT を先に配線する**：XIAO 裏面の VBAT パッドに細い電線（またはピン）をはんだ付けし、メイン基板の「VBAT」の穴に通してから XIAO をピンヘッダに載せる。XIAO を付けた後では VBAT パッドに手が届きません。
2. **昇圧モジュールの向き**：J2 の角パッド（右端）が 1番（GND）。モジュールの 1番（角パッド）と合わせて、基板に垂直に立てて差す。
3. **電源スイッチ**：J3 の BAT+ と SW の間を ON/OFF するスイッチを、ケースに付けて電線でつなぐ。
4. **AM312**：J1 に電線でつなぐ。AM312 の VCC / OUT / GND の並びは製品によって違うので、AM312 側の表示で確認すること。

## 未確認のこと（試作前に確認してください）

- **XIAO の VBAT パッドの位置**：Seeed 公式の KiCad フットプリント（XIAO-nRF52840-SMD）から換算した位置です。実物と照らし合わせてください（電線でつなぐので多少ずれても問題ありません）。
- **Choc スイッチの穴寸法**：keyswitch-kicad-library の Kailh Choc V1 と同じ寸法で作りました。実物のスイッチで穴に合うか確認してください。
- **電池ホルダーとエネループの相性**：Keystone 2466 の寸法は KiCad 標準ライブラリのものです。
- **高さ**：昇圧モジュールを垂直に立てると基板から約13mm、Choc スイッチ＋キーキャップは約8mm になります。ケースの設計で考慮してください。

## ファイル

| ファイル | 内容 |
|---|---|
| `pir_switch_main.kicad_pro` / `.kicad_sch` / `.kicad_pcb` | KiCad 9 プロジェクト |
| `pir_switch.pretty/` | 専用フットプリント（XIAO、Choc V1、昇圧モジュール用 5 ピン端子） |
| `pir_switch.kicad_sym` | 専用シンボル（XIAO nRF52840） |
| `pir_switch_main_schematic.pdf` | 回路図の PDF |
| `production/pir_switch_main_gerbers.zip` | 基板メーカーに送る製造データ（ガーバー＋ドリル） |
| `production/bom.csv` | 部品表 |

Parts:
BT1: Eneloop AAA (1.2V); BatteryHolder_Keystone_2466_1xAAA
H1, H2, H3: M2; MountingHole_2.2mm_M2
J1: AM312 (VCC, OUT, GND); PinHeader_1x03_P2.54mm_Vertical
J2: aaa-boost-module-v2; Header_1x05_P2.54mm_Compact
J3: Power switch; PinHeader_1x02_P2.54mm_Vertical
SW1: Choc SW_A (mode 1); Kailh_Choc_V1
SW2: Choc SW_B (mode 2); Kailh_Choc_V1
U1: XIAO nRF52840; XIAO_nRF52840_THT_VBAT

Connections:
/+3V3: J1.1, U1.12 (3V3)
/BAT_P: BT1.1 (+), J3.1
/BAT_SNS: J2.3, U1.4 (D3)
/BAT_SW: J2.5, J3.2
/D0_PIR: J1.2, U1.1 (D0)
/D1_SW_A: SW1.2, U1.2 (D1)
/D2_SW_B: SW2.2, U1.3 (D2)
/GND: BT1.2 (-), J1.3, J2.1, SW1.1, SW2.1, U1.13 (GND)
/VBAT: J2.4, U1.15 (VBAT)
/VBUS: J2.2, U1.14 (5V)

Notes on the sheet:
J1: AM312 は電線でつなぐ（VCC / OUT / GND の順番は AM312 側の表示で確認）
J2: 昇圧モジュール aaa-boost-module-v2（1 GND, 2 5V, 3 SNS, 4 MCU, 5 BAT）
J3: 電源スイッチを電線でつなぐ（電池+ と 昇圧モジュール BAT の間を ON/OFF）
U1 pin 15: XIAO 裏面の VBAT パッドと電線でつなぐ

Board: 2 copper layers, 62.0 x 41.0 mm, 10 parts (0 on the bottom side), 10 nets.

File hardware/pir_switch_main/production/bom.csv:

"Reference","Value","Footprint","Qty"
"BT1","Eneloop AAA (1.2V)","Battery:BatteryHolder_Keystone_2466_1xAAA","1"
"J1","AM312 (VCC, OUT, GND)","Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical","1"
"J2","aaa-boost-module-v2","pir_switch:Header_1x05_P2.54mm_Compact","1"
"J3","Power switch","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","1"
"SW1","Choc SW_A (mode 1)","pir_switch:Kailh_Choc_V1","1"
"SW2","Choc SW_B (mode 2)","pir_switch:Kailh_Choc_V1","1"
"U1","XIAO nRF52840","pir_switch:XIAO_nRF52840_THT_VBAT","1"
